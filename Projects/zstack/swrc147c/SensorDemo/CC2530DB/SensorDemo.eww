<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SensorDemo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>SensorDemo</project>
        <configuration>CollectorEB</configuration>
      </member>
      <member>
        <project>SensorDemo</project>
        <configuration>SensorEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


